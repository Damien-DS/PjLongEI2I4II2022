# Keil uVision project RTOSDemo.uvprojx, settings and files
target RTOSDemo_THUMB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: KEIL_THUMB_INTERWORK
  c include: .;..\..\Source\portable\RVDS\ARM_CM3;..\Common\include;..\..\Source\include
  asm include: ..\..\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Other
    ./: main.c myTasks.c
  group FreeRTOS
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
